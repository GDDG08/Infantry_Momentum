# Keil uVision project Infantry_Momentum.uvprojx, settings and files
target Infantry_Momentum (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry_Momentum +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__TARGET_FPU_VFP,__CC_ARM
  c include: ../Core/Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc;           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;           ../Middlewares/Third_Party/FreeRTOS/Source/include;           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;           ../Drivers/CMSIS/Include;           ..\Drivers\CMSIS\DSP\Include;           ..\Core\Inc;           ..\Core\Inc\Algorithm;           ..\Core\Inc\Library;           ..\Core\Inc\Peripheral;           ..\Core\Inc\Utility;           ..\Core\Inc\Chassis_Control;           ..\Core\Inc\Gimbal_Control;           ..\Core\Inc\SuperCap_Control;           ..\Core\Inc\Common_Contrrol
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Inc/: configure.h
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dac.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/: arm_cortexM4lf_math.lib
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Utility
    ../Core/Src/Utility/: can_util.c uart_util.c pwm_util.c gpio_util.c adc_util.c dac_util.c
  group Peripheral
    ../Core/Src/Peripheral/: imu_periph.c led_periph.c miniPC_periph.c motor_periph.c referee_periph.c remote_periph.c sensor_periph.c servo_periph.c
  group Library
    ../Core/Src/Library/: const_lib.c log_lib.c buff_lib.c
  group Algorithm
    ../Core/Src/Algorithm/: pid_alg.c math_alg.c filter_alg.c kalman_alg.c
  group Gimbal_Control
    ../Core/Src/Algorithm/: crc_alg.c
    ../Core/Src/Gimbal_Control/: gim_gimbal_ctrl.c gim_miniPC_ctrl.c gim_remote_ctrl.c gim_shoot_ctrl.c
  group Chassis_Control
    ../Core/Src/Chassis_Control/: cha_gimbal_ctrl.c cha_chassis_ctrl.c cha_power_ctrl.c cha_referee_ctrl.c
  group SuperCap_Control
    ../Core/Src/SuperCap_Control/: supercap_ctrl.c supercap_comm.c
  group Common_Control
    ../Core/Src/Common_Contrrol/: buscomm_ctrl.c init_ctrl.c watchdog_ctrl.c buscomm_cmd.c
software components: CMSIS:CORE 4.3.0
